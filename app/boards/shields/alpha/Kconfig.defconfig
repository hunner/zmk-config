## config/boards/shields/pain27/Kconfig.defconfig
```kconfig
if SHIELD_pain27

config ZMK_KEYBOARD_NAME
    default "Pain27"
	
endif # BOARD_pain27
```
